# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Hardware;.\Delay
  group Source Group 1
    ./: STARTUP.A51 main.c
    ./Hardware/: oled.c DS1302.c key.c Timer0.c
    ./Delay/: Delay.c
